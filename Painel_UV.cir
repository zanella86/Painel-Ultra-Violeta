.title KiCad schematic
R1 NC_01 Net-_D1-Pad2_ 56
D3 NC_02 Net-_D2-Pad1_ LED
J2 /VCC /GND Screw_Terminal_01x02
J1 /VCC /GND Conn_01x02_Male
D2 Net-_D2-Pad1_ Net-_D1-Pad1_ LED
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ LED
R2 NC_03 Net-_D4-Pad2_ 56
D6 NC_04 Net-_D5-Pad1_ LED
D5 Net-_D5-Pad1_ Net-_D4-Pad1_ LED
D4 Net-_D4-Pad1_ Net-_D4-Pad2_ LED
R3 NC_05 Net-_D7-Pad2_ 56
D9 NC_06 Net-_D8-Pad1_ LED
D8 Net-_D8-Pad1_ Net-_D7-Pad1_ LED
D7 Net-_D7-Pad1_ Net-_D7-Pad2_ LED
R4 NC_07 Net-_D10-Pad2_ 56
D12 NC_08 Net-_D11-Pad1_ LED
D11 Net-_D11-Pad1_ Net-_D10-Pad1_ LED
D10 Net-_D10-Pad1_ Net-_D10-Pad2_ LED
R5 NC_09 Net-_D13-Pad2_ 56
D15 NC_10 Net-_D14-Pad1_ LED
D14 Net-_D14-Pad1_ Net-_D13-Pad1_ LED
D13 Net-_D13-Pad1_ Net-_D13-Pad2_ LED
R6 NC_11 Net-_D16-Pad2_ 56
D18 NC_12 Net-_D17-Pad1_ LED
D17 Net-_D17-Pad1_ Net-_D16-Pad1_ LED
D16 Net-_D16-Pad1_ Net-_D16-Pad2_ LED
R12 NC_13 Net-_D34-Pad2_ 56
D36 NC_14 Net-_D35-Pad1_ LED
D35 Net-_D35-Pad1_ Net-_D34-Pad1_ LED
D34 Net-_D34-Pad1_ Net-_D34-Pad2_ LED
R11 NC_15 Net-_D31-Pad2_ 56
D33 NC_16 Net-_D32-Pad1_ LED
D32 Net-_D32-Pad1_ Net-_D31-Pad1_ LED
D31 Net-_D31-Pad1_ Net-_D31-Pad2_ LED
R10 NC_17 Net-_D28-Pad2_ 56
D30 NC_18 Net-_D29-Pad1_ LED
D29 Net-_D29-Pad1_ Net-_D28-Pad1_ LED
D28 Net-_D28-Pad1_ Net-_D28-Pad2_ LED
R9 NC_19 Net-_D25-Pad2_ 56
D27 NC_20 Net-_D26-Pad1_ LED
D26 Net-_D26-Pad1_ Net-_D25-Pad1_ LED
D25 Net-_D25-Pad1_ Net-_D25-Pad2_ LED
R8 NC_21 Net-_D22-Pad2_ 56
D24 NC_22 Net-_D23-Pad1_ LED
D23 Net-_D23-Pad1_ Net-_D22-Pad1_ LED
D22 Net-_D22-Pad1_ Net-_D22-Pad2_ LED
R7 NC_23 Net-_D19-Pad2_ 56
D21 NC_24 Net-_D20-Pad1_ LED
D20 Net-_D20-Pad1_ Net-_D19-Pad1_ LED
D19 Net-_D19-Pad1_ Net-_D19-Pad2_ LED
.end
